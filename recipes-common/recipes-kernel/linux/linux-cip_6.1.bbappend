FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
file://panfrost_6.1.cfg \
"
